# Keil uVision project freertos_template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: freertos_template +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F3
  c include: ..\includes;..\..\common\includes;..\..\CMSIS\Include;..\..\CMSIS\Device\ST\STM32F30x\Include;..\..\STM32F30x_StdPeriph_Driver\inc;..\..\..\RTOS\FreeRTOSV7.5.3\FreeRTOS\Source\include;..\..\..\RTOS\FreeRTOSV7.5.3\FreeRTOS\Source\portable\MemMang;..\..\..\RTOS\FreeRTOSV7.5.3\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application
    ./: startup_stm32f30x.s
    ../src/: leds.c main.c stm32f30x_it.c task1.c timer2.c
  group Common
    ../../common/src/: syscalls.c system_stm32f30x.c
  group STM32F3 Library
    ../../STM32F30x_StdPeriph_Driver/src/: stm32f30x_adc.c stm32f30x_can.c stm32f30x_comp.c stm32f30x_crc.c stm32f30x_dac.c stm32f30x_dbgmcu.c stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_iwdg.c stm32f30x_misc.c stm32f30x_opamp.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_rtc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_tim.c stm32f30x_usart.c stm32f30x_wwdg.c
  group FreeRTOS
    ../../../RTOS/FreeRTOSV7.5.3/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../RTOS/FreeRTOSV7.5.3/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../RTOS/FreeRTOSV7.5.3/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
