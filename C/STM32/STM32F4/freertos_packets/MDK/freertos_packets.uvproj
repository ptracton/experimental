# Keil uVision project freertos_packets.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: freertos_packets
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\includes;..\..\common\includes;..\..\STM32F4xx_StdPeriph_Driver\inc;..\..\CMSIS\Include;..\..\CMSIS\ST\STM32F4xx\Include;..\..\..\RTOS\FreeRTOSV7.5.3\FreeRTOS\Source\include;..\..\..\RTOS\FreeRTOSV7.5.3\FreeRTOS\Source\portable\MemMang;..\..\..\RTOS\FreeRTOSV7.5.3\FreeRTOS\Source\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./: startup_stm32f40xx.s
    ../src/: communication.c main.c stm32f4xx_it.c task1.c timer2.c
  group Common
    ../../common/src/: leds.c syscalls.c system_stm32f4xx.c
  group STM32F4 Drivers
    ../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_crc.c stm32f4xx_dbgmcu.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group FreeRTOS
    ../../../RTOS/FreeRTOSV7.5.3/FreeRTOS/Source/: croutine.c list.c queue.c tasks.c timers.c
    ../../../RTOS/FreeRTOSV7.5.3/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../RTOS/FreeRTOSV7.5.3/FreeRTOS/Source/portable/MemMang/: heap_1.c
