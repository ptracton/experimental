# Keil uVision project ucosii_template.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: ucosii_template +hex
  c flags: Optim=1 oTime=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\includes;..\..\CMSIS\Include;..\..\CMSIS\ST\STM32F4xx\Include;..\..\common\includes;..\..\STM32F4xx_StdPeriph_Driver\inc;..\..\..\RTOS\Micrium\Software\uCOS-II\Source;..\..\..\RTOS\Micrium\Software\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;..\..\..\RTOS\Micrium\Software\uC-LIB;..\..\..\RTOS\Micrium\Software\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\..\RTOS\Micrium\Software\uC-CPU\ARM-Cortex-M4\RealView;..\..\..\RTOS\Micrium\Software\uC-CPU
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../src/: app_hooks.c main.c stm32f4xx_it.c app.c bsp.c task1.c leds.c
  group Common
    ../../common/src/: system_stm32f4xx.c startup_stm32f40xx.s
  group STM32F4 Libraries
    ../../STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group uCOS-II
    ../../../RTOS/Micrium/Software/uCOS-II/Source/: ucos_ii.c
    ../../../RTOS/Micrium/Software/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu_c.c os_dbg.c os_cpu_a.asm
    ../../../RTOS/Micrium/Software/uC-CPU/: cpu_core.c
    ../../../RTOS/Micrium/Software/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
    ../../../RTOS/Micrium/Software/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../../RTOS/Micrium/Software/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
